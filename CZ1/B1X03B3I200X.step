One B-rep face of a CAD part: STEP entity #1405.
In plain terms, the planar face has unit normal (0, -1, 0).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#5 = VECTOR ( 'NONE', #556, 1000. ) ;
#36 = LINE ( 'NONE', #826, #820 ) ;
#41 = LINE ( 'NONE', #440, #5 ) ;
#47 = CARTESIAN_POINT ( 'NONE',  ( 102., 0., 1500. ) ) ;
#75 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., -1479. ) ) ;
#102 = LINE ( 'NONE', #1096, #704 ) ;
#103 = EDGE_CURVE ( 'NONE', #1295, #801, #41, .T. ) ;
#110 = VECTOR ( 'NONE', #1275, 1000. ) ;
#155 = LINE ( 'NONE', #455, #1084 ) ;
#158 = ORIENTED_EDGE ( 'NONE', *, *, #891, .T. ) ;
#178 = DIRECTION ( 'NONE',  ( 1., 0., 0. ) ) ;
#187 = EDGE_CURVE ( 'NONE', #700, #405, #1646, .T. ) ;
#202 = VERTEX_POINT ( 'NONE', #245 ) ;
#245 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., 1500. ) ) ;
#255 = VERTEX_POINT ( 'NONE', #1301 ) ;
#263 = ORIENTED_EDGE ( 'NONE', *, *, #862, .T. ) ;
#268 = ORIENTED_EDGE ( 'NONE', *, *, #1169, .F. ) ;
#289 = LINE ( 'NONE', #930, #1420 ) ;
#333 = EDGE_LOOP ( 'NONE', ( #705, #919, #1314, #796 ) ) ;
#345 = DIRECTION ( 'NONE',  ( 0., 0., -1. ) ) ;
#362 = VECTOR ( 'NONE', #1026, 1000. ) ;
#394 = EDGE_CURVE ( 'NONE', #1501, #1302, #554, .T. ) ;
#396 = EDGE_CURVE ( 'NONE', #202, #1501, #155, .T. ) ;
#405 = VERTEX_POINT ( 'NONE', #1347 ) ;
#440 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., -1479. ) ) ;
#455 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., 1500. ) ) ;
#459 = ORIENTED_EDGE ( 'NONE', *, *, #103, .T. ) ;
#486 = FACE_OUTER_BOUND ( 'NONE', #333, .T. ) ;
#503 = EDGE_LOOP ( 'NONE', ( #1503, #1021, #268, #1277 ) ) ;
#530 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., 1488. ) ) ;
#554 = LINE ( 'NONE', #47, #1191 ) ;
#556 = DIRECTION ( 'NONE',  ( 1., 0., 0. ) ) ;
#562 = DIRECTION ( 'NONE',  ( 0., 0., -1. ) ) ;
#563 = EDGE_LOOP ( 'NONE', ( #1349, #459, #263, #158 ) ) ;
#600 = VECTOR ( 'NONE', #1410, 1000. ) ;
#612 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., -1488. ) ) ;
#623 = EDGE_CURVE ( 'NONE', #202, #750, #869, .T. ) ;
#638 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., 1500. ) ) ;
#679 = EDGE_CURVE ( 'NONE', #750, #1302, #766, .T. ) ;
#700 = VERTEX_POINT ( 'NONE', #1177 ) ;
#701 = EDGE_CURVE ( 'NONE', #1315, #255, #1300, .T. ) ;
#704 = VECTOR ( 'NONE', #878, 1000. ) ;
#705 = ORIENTED_EDGE ( 'NONE', *, *, #679, .T. ) ;
#717 = VERTEX_POINT ( 'NONE', #1544 ) ;
#750 = VERTEX_POINT ( 'NONE', #1408 ) ;
#766 = LINE ( 'NONE', #902, #362 ) ;
#787 = CARTESIAN_POINT ( 'NONE',  ( 102., 0., 1500. ) ) ;
#796 = ORIENTED_EDGE ( 'NONE', *, *, #623, .T. ) ;
#801 = VERTEX_POINT ( 'NONE', #1590 ) ;
#820 = VECTOR ( 'NONE', #834, 1000. ) ;
#826 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., 1488. ) ) ;
#834 = DIRECTION ( 'NONE',  ( -1., 0., 0. ) ) ;
#862 = EDGE_CURVE ( 'NONE', #801, #1063, #1643, .T. ) ;
#867 = DIRECTION ( 'NONE',  ( 0., 1., 0. ) ) ;
#869 = LINE ( 'NONE', #638, #110 ) ;
#878 = DIRECTION ( 'NONE',  ( -1., 0., 0. ) ) ;
#891 = EDGE_CURVE ( 'NONE', #1063, #717, #102, .T. ) ;
#892 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., -1488. ) ) ;
#902 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., -1500. ) ) ;
#919 = ORIENTED_EDGE ( 'NONE', *, *, #394, .F. ) ;
#930 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., 1479. ) ) ;
#981 = CARTESIAN_POINT ( 'NONE',  ( 102., 0., -1500. ) ) ;
#982 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., 1500. ) ) ;
#999 = FACE_BOUND ( 'NONE', #563, .T. ) ;
#1021 = ORIENTED_EDGE ( 'NONE', *, *, #701, .F. ) ;
#1026 = DIRECTION ( 'NONE',  ( 1., 0., 0. ) ) ;
#1030 = LINE ( 'NONE', #1558, #1444 ) ;
#1050 = DIRECTION ( 'NONE',  ( 0., 0., -1. ) ) ;
#1063 = VERTEX_POINT ( 'NONE', #892 ) ;
#1070 = DIRECTION ( 'NONE',  ( 1., 0., 0. ) ) ;
#1084 = VECTOR ( 'NONE', #1070, 1000. ) ;
#1096 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., -1488. ) ) ;
#1169 = EDGE_CURVE ( 'NONE', #405, #1315, #36, .T. ) ;
#1177 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., 1479. ) ) ;
#1191 = VECTOR ( 'NONE', #562, 1000. ) ;
#1264 = PLANE ( 'NONE',  #1608 ) ;
#1275 = DIRECTION ( 'NONE',  ( 0., 0., -1. ) ) ;
#1277 = ORIENTED_EDGE ( 'NONE', *, *, #187, .F. ) ;
#1295 = VERTEX_POINT ( 'NONE', #75 ) ;
#1300 = LINE ( 'NONE', #530, #1361 ) ;
#1301 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., 1479. ) ) ;
#1302 = VERTEX_POINT ( 'NONE', #981 ) ;
#1312 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., 1488. ) ) ;
#1314 = ORIENTED_EDGE ( 'NONE', *, *, #396, .F. ) ;
#1315 = VERTEX_POINT ( 'NONE', #1312 ) ;
#1347 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., 1488. ) ) ;
#1349 = ORIENTED_EDGE ( 'NONE', *, *, #1463, .T. ) ;
#1361 = VECTOR ( 'NONE', #1050, 1000. ) ;
#1404 = FACE_BOUND ( 'NONE', #503, .T. ) ;
#1405 = ADVANCED_FACE ( 'NONE', ( #486, #1404, #999 ), #1264, .F. ) ;
#1408 = CARTESIAN_POINT ( 'NONE',  ( -102., 0., -1500. ) ) ;
#1410 = DIRECTION ( 'NONE',  ( 0., 0., 1. ) ) ;
#1420 = VECTOR ( 'NONE', #178, 1000. ) ;
#1427 = DIRECTION ( 'NONE',  ( 0., 0., 1. ) ) ;
#1444 = VECTOR ( 'NONE', #1427, 1000. ) ;
#1463 = EDGE_CURVE ( 'NONE', #717, #1295, #1030, .T. ) ;
#1495 = DIRECTION ( 'NONE',  ( -1., 0., 0. ) ) ;
#1501 = VERTEX_POINT ( 'NONE', #787 ) ;
#1503 = ORIENTED_EDGE ( 'NONE', *, *, #1600, .F. ) ;
#1510 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., 1488. ) ) ;
#1526 = VECTOR ( 'NONE', #345, 1000. ) ;
#1544 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., -1488. ) ) ;
#1558 = CARTESIAN_POINT ( 'NONE',  ( -3.25, 0., -1488. ) ) ;
#1590 = CARTESIAN_POINT ( 'NONE',  ( 3.25, 0., -1479. ) ) ;
#1600 = EDGE_CURVE ( 'NONE', #255, #700, #289, .T. ) ;
#1608 = AXIS2_PLACEMENT_3D ( 'NONE', #982, #867, #1495 ) ;
#1643 = LINE ( 'NONE', #612, #1526 ) ;
#1646 = LINE ( 'NONE', #1510, #600 ) ;
